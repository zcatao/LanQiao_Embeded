# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\USMART;..\FWLIB\inc;..\MALLOC;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWARE\24C02;..\HAREWARE\ADC;..\HAREWARE\BEEP;..\HAREWARE\EXTI;..\HAREWARE\IIC;..\HAREWARE\KEY;..\HAREWARE\LCD;..\HAREWARE\LED;..\HAREWARE\RTC;..\HAREWARE\SD;..\HAREWARE\SPI;..\HAREWARE\TIMER;..\HAREWARE\TOUCH;..\HAREWARE\WDG;..\HAREWARE\WKUP
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group Fwlib
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Hardware
    ../HAREWARE/LCD/: lcd.c
    ../HAREWARE/LED/: led.c
    ../HAREWARE/ADC/: adc.c
    ../HAREWARE/RTC/: rtc.c
    ../HAREWARE/KEY/: key.c
    ../HAREWARE/TIMER/: timer.c
    ../HAREWARE/IIC/: iic.c
    ../HAREWARE/24C02/: 24c02.c
  group User
    ./: main.c system_stm32f10x.c display.c
